Commit message: fixed spinning issue

File: SurRoL_dVTainer/surrol/assets/block/block.urdf (robot description, URDF)
Before this commit: robot block, 4 links, 3 joints
Links:
- link baseLink: mass 0.3 -> 1
